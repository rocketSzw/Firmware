## src/modules/master_slave/Kconfig
```kconfig
menuconfig MODULES_MASTER_SLAVE
	bool "master_slave"
	default n
	---help---
		Enable support for master_slave
```
